# Keil uVision project UARTInts.uvproj, settings and files
target UARTInts (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: UARTInts
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: -D__MICROLIB --c99
  c include: ..;..\..\..
  asm misc: --pd "__MICROLIB SETA 1"
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c ST7735.c ADC.c OS.c ThreadSwitch.s SysTick.c WTimer5A.c WTimer0B.c WTimer0A.c can.c can0.c cpu.c FIFO.c interrupt.c Robot.c usonic.c PWM.c
