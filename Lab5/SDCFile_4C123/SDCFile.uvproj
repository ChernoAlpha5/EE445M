# Keil uVision project SDCFile.uvproj, settings and files
target SDCFile (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: SDCFile
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR VALVANOWARE
  c misc: --C99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s diskio.c ff.c PLL.c SDCFile.c ST7735.c heap.c Interpreter.c OS.c SysTick.c UART2.c ThreadSwitch.s loader.c
